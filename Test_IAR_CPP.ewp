# IAR project Test_IAR_CPP.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F107xB ST STM32F107xB
  ICCARM.PreInclude: D:\Test_IAR\Header\Test.h
  ICCARM.CCIncludePath2: Header\; Source\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Test_IAR_CPP.srec
  ILINK.IlinkOutputFile: Test_IAR_CPP.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ./: main.cpp
  group Header
    Header/: Test.h
  group Source
    Source/: Test.cpp
